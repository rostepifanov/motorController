# Keil uVision project motorController.uvprojx, settings and files
target driverController (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motorController
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startPoint
    ./: main.c
  group init
    ./: initModule.h initModule.c pinRegistration.c pinRegistration.h
  group movingControl
    ./: movingControl.h movingControl.c pinOutputChanging.c pinOutputChanging.h motorHardDescription.c motorHardDescription.h motorDescription.h
  group timeControl
    ./: timeControl.h timeControl.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
